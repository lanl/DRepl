## kdreplfs/Kconfig
```kconfig
config DREPL_FS
	tristate "Dreplfs file system (EXPERIMENTAL)"
	depends on EXPERIMENTAL
	help
	  Dreplfs
```
